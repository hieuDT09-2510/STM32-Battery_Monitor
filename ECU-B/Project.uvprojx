# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\User;.\Library;.\FreeRtos;.\FreeRtos\inc;.\FreeRtos\port;.\FreeRtos\src;.\App;.\Bsp;.\Bsp\inc;.\Bsp\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c
  group FreeRtos/inc
    ./FreeRtos/: FreeRTOSConfig.h
    ./FreeRtos/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRtos/src
    ./FreeRtos/src/: list.c queue.c tasks.c croutine.c event_groups.c stream_buffer.c timers.c
  group FreeRtos/port
    ./FreeRtos/port/: heap_4.c port.c
    ./FreeRtos/: freertos_hooks.c
  group App
    ./App/: app_dash.c app_dash.h
  group Bsp
    ./Bsp/: bsp_can.c bsp_can.h bsp_gpio.c bsp_gpio.h bsp_i2c.c bsp_i2c.h bsp_oled.c bsp_oled.h bsp_tim.c bsp_tim.h bsp_usart.c bsp_usart.h can_protocol.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:CAN 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
