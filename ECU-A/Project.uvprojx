# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\User;.\Library;.\FreeRtos;.\FreeRtos\inc;.\FreeRtos\port;.\FreeRtos\src;.\App;.\Bsp;.\Bsp\inc;.\Bsp\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c
  group FreeRtos/inc
    ./FreeRtos/: FreeRTOSConfig.h
    ./FreeRtos/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRtos/src
    ./FreeRtos/src/: list.c queue.c tasks.c croutine.c event_groups.c stream_buffer.c timers.c
  group FreeRtos/port
    ./FreeRtos/port/: heap_4.c port.c
    ./FreeRtos/: freertos_hooks.c
  group App
    ./App/: app_cli.c app_cli.h app_bms_state.c app_bms_state.h app_event.c app_event.h app_flash_log.c app_flash_log.h app_sensor.c app_sensor.h app_soc.c app_soc.h app_flash_access.c app_flash_access.h app_fault_manager.c app_fault_manager.h app_fault_event.c app_fault_event.h app_health_monitor.c app_health_monitor.h app_rtos.c app_rtos.h app_can_service.c app_can_service.h
  group Bsp
    ./Bsp/: bsp_adc_dma.c bsp_adc_dma.h bsp_can.c bsp_can.h bsp_gpio.c bsp_gpio.h bsp_load_switch.c bsp_load_switch.h bsp_spi_flash.c bsp_spi_flash.h bsp_tim.c bsp_tim.h bsp_usart.c bsp_usart.h can_protocol.h bsp_buzzer.c bsp_buzzer.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:CAN 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
